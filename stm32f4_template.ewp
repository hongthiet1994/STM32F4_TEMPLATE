# IAR project stm32f4_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM324x9I_EVAL
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\STM32F4xx_StdPeriph_Driver\inc; Utilities\STM32_EVAL\Common; Utilities\STM32_EVAL\STM324x9I_EVAL; Libraries\CMSIS\Device\ST\STM32F4xx\Include; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\1.PKH\1.Project\40.TEMPLATE_STM32F4\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ./: system_stm32f4xx.c
  group EWARM
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group User
    ./: main.c stm32f4xx_it.c stm32f4xx_it.h
